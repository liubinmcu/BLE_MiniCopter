# IAR project BLE_MiniCopter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; NRF51422; BOARD_PCA10028; NRF_SD_BLE_API_VERSION=2; S130; NRF51; SOFTDEVICE_PRESENT; SWI_DISABLE0; FREERTOS; __STACK_SIZE=2048; __HEAP_SIZE=1024
  ICCARM.CCIncludePath2: ..\Application; ..\Board_Definition; ..\Device; ..\App_Drivers; ..\App_Tasks; ..\nRF_Drivers\hal; ..\nRF_Drivers\delay; ..\nRF_Drivers\clock; ..\nRF_Drivers\common; ..\nRF_Drivers\gpiote; ..\nRF_Drivers\uart; ..\nRF_Drivers\ppi; ..\nRF_Drivers\timer; ..\nRF_Libraries\bsp; ..\nRF_Libraries\button; ..\nRF_Libraries\pwm; ..\nRF_Libraries\fifo; ..\nRF_Libraries\fstorage; ..\nRF_Libraries\gpiote; ..\nRF_Libraries\hardfault; ..\nRF_Libraries\log; ..\nRF_Libraries\log\src; ..\nRF_Libraries\timer; ..\nRF_Libraries\uart; ..\nRF_Libraries\util; ..\nRF_Libraries\experimental_section_vars; ..\nRF_Segger_RTT; ..\nRF_SoftDevice\common\softdevice_handler; ..\nRF_SoftDevice\s130\headers; ..\nRF_BLE\ble_advertising; ..\nRF_BLE\common; ..\nRF_BLE\ble_services\ble_nus; ..\RTOS\freertos\config; ..\RTOS\freertos\portable\CMSIS\nrf51; ..\RTOS\freertos\portable\IAR\nrf51; ..\RTOS\freertos\source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: BLE_MiniCopter.out
  ILINK.IlinkIcfFile: ble_app_uart_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App_Drivers
    ../App_Drivers/: app_drv_button.c app_drv_led.c app_drv_pwm.c app_drv_uart.c
  group App_Tasks
    ../App_Tasks/: app_task_comm.c app_task_led.c app_task_main.c app_task_pwm.c
  group Application
    ../Application/: app_global_include.h FreeRTOSConfig.h main.c sdk_config.h
  group Board_Definition
    ../Board_Definition/: boards.c bsp_hardware.c
  group Board_Support
    ../nRF_Libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group Device
    ../Device/: iar_startup_nrf51.s system_nrf51.c
  group nRF_BLE
    ../nRF_BLE/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../nRF_BLE/ble_advertising/: ble_advertising.c
  group nRF_BLE_Services
    ../nRF_BLE/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../nRF_Drivers/clock/: nrf_drv_clock.c
    ../nRF_Drivers/common/: nrf_drv_common.c
    ../nRF_Drivers/gpiote/: nrf_drv_gpiote.c
    ../nRF_Drivers/ppi/: nrf_drv_ppi.c
    ../nRF_Drivers/timer/: nrf_drv_timer.c
    ../nRF_Drivers/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../nRF_Libraries/button/: app_button.c
    ../nRF_Libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../nRF_Libraries/fifo/: app_fifo.c
    ../nRF_Libraries/pwm/: app_pwm.c
    ../nRF_Libraries/timer/: app_timer_freertos.c
    ../nRF_Libraries/uart/: app_uart_fifo.c retarget.c
    ../nRF_Libraries/fstorage/: fstorage.c
    ../nRF_Libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../nRF_Libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../nRF_Segger_RTT/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../nRF_SoftDevice/common/softdevice_handler/: softdevice_handler.c
  group RTOS
    ../RTOS/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../RTOS/freertos/source/portable/MemMang/: heap_1.c
    ../RTOS/freertos/portable/IAR/nrf51/: port.c
    ../RTOS/freertos/portable/CMSIS/nrf51/: port_cmsis.c port_cmsis_systick.c
