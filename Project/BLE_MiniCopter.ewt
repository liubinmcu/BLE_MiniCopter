<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App_Drivers</name>
    <file>
      <name>$PROJ_DIR$\..\App_Drivers\app_drv_button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App_Drivers\app_drv_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App_Drivers\app_drv_pwm.c</name>
    </file>
  </group>
  <group>
    <name>App_Tasks</name>
    <file>
      <name>$PROJ_DIR$\..\App_Tasks\app_task_comm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App_Tasks\app_task_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App_Tasks\app_task_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App_Tasks\app_task_pwm.c</name>
    </file>
  </group>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\Application\app_global_include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\FreeRTOSConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Application\sdk_config.h</name>
    </file>
  </group>
  <group>
    <name>Board_Definition</name>
    <file>
      <name>$PROJ_DIR$\..\Board_Definition\boards.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Board_Definition\bsp_hardware.c</name>
    </file>
  </group>
  <group>
    <name>Board_Support</name>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\bsp\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\bsp\bsp_btn_ble.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\bsp\bsp_nfc.c</name>
    </file>
  </group>
  <group>
    <name>Device</name>
    <file>
      <name>$PROJ_DIR$\..\Device\iar_startup_nrf51.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Device\system_nrf51.c</name>
    </file>
  </group>
  <group>
    <name>nRF_BLE</name>
    <file>
      <name>$PROJ_DIR$\..\nRF_BLE\common\ble_advdata.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_BLE\ble_advertising\ble_advertising.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_BLE\common\ble_conn_params.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_BLE\common\ble_srv_common.c</name>
    </file>
  </group>
  <group>
    <name>nRF_BLE_Services</name>
    <file>
      <name>$PROJ_DIR$\..\nRF_BLE\ble_services\ble_nus\ble_nus.c</name>
    </file>
  </group>
  <group>
    <name>nRF_Drivers</name>
    <file>
      <name>$PROJ_DIR$\..\nRF_Drivers\clock\nrf_drv_clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Drivers\common\nrf_drv_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Drivers\gpiote\nrf_drv_gpiote.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Drivers\ppi\nrf_drv_ppi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Drivers\timer\nrf_drv_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Drivers\uart\nrf_drv_uart.c</name>
    </file>
  </group>
  <group>
    <name>nRF_Libraries</name>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\button\app_button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\util\app_error.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\util\app_error_weak.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\fifo\app_fifo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\pwm\app_pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\timer\app_timer_freertos.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\uart\app_uart_fifo.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\util\app_util_platform.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\fstorage\fstorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\hardfault\hardfault_implementation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\util\nrf_assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\uart\retarget.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\util\sdk_errors.c</name>
    </file>
  </group>
  <group>
    <name>nRF_Log</name>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\log\src\nrf_log_backend_serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Libraries\log\src\nrf_log_frontend.c</name>
    </file>
  </group>
  <group>
    <name>nRF_Segger_RTT</name>
    <file>
      <name>$PROJ_DIR$\..\nRF_Segger_RTT\RTT_Syscalls_IAR.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Segger_RTT\SEGGER_RTT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\nRF_Segger_RTT\SEGGER_RTT_printf.c</name>
    </file>
  </group>
  <group>
    <name>nRF_SoftDevice</name>
    <file>
      <name>$PROJ_DIR$\..\nRF_SoftDevice\common\softdevice_handler\softdevice_handler.c</name>
    </file>
  </group>
  <group>
    <name>RTOS</name>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\source\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\source\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\source\portable\MemMang\heap_1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\portable\IAR\nrf51\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\portable\CMSIS\nrf51\port_cmsis.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\portable\CMSIS\nrf51\port_cmsis_systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\RTOS\freertos\source\timers.c</name>
    </file>
  </group>
</project>


